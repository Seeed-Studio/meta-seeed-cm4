FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

KBUILD_DEFCONFIG:seeed-recomputer-r2x ?= "bcm2712_defconfig"
